<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.14'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Zhenlin</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>920e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_SQR_WAVE</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>filerepeater_AdvFileSink</key>
<param><key>id</key><value>filerepeater_AdvFileSink_0</value></param>
<param><key>autostartFreqChange</key><value>False</value></param>
<param><key>basedir</key><value>../misc/</value></param>
<param><key>basefile</key><value>test</value></param>
<param><key>bits_per_sample</key><value>8</value></param>
<param><key>unbuffered</key><value>True</value></param>
<param><key>radioCenterFreq</key><value>freq</value></param>
<param><key>honorFreqChange</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxSize</key><value>int(10e6)</value></param>
<param><key>maxTimeSec</key><value>1</value></param>
<param><key>recordOnStart</key><value>True</value></param>
<param><key>sampleRate</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>filerepeater_StateTimer</key>
<param><key>id</key><value>filerepeater_StateTimer_0</value></param>
<param><key>cycleTime</key><value>0.1</value></param>
<param><key>delayBeforeStart</key><value>0.0</value></param>
<param><key>triggerTime</key><value>0.01</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>filerepeater_StateTimer_0</source_block_id><sink_block_id>filerepeater_AdvFileSink_0</sink_block_id><source_key>trigger</source_key><sink_key>recordstate</sink_key></connection>
</flow_graph>
